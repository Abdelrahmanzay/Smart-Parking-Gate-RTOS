# Keil uVision project project1.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=1
  c include: ..\Test;.;.\inc;.\Required_Files;.\RTE\_Target_1;.\RTE\Device\TM4C123GH6PM;.\FreeRTOS\include;.\FreeRTOS\portable\GCC\ARM_CM4F;D:\UNI\semester 6\advanced embedded\Project-Simulator\Project-Simulator\FreeRTOS\include;D:\UNI\semester 6\advanced embedded\Project-Simulator\Project-Simulator\FreeRTOS\portable\GCC\ARM_CM4F
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c gpio.c adc.c uart.c tasks.c fsm.c
  group FreeRTOS Kernel
    ./FreeRTOS/: freertos_list.c freertos_queue.c freertos_tasks.c
    ./FreeRTOS/portable/GCC/ARM_CM4F/: freertos_port.c
    ./FreeRTOS/portable/MemMang/: freertos_heap_4.c
software components: CMSIS:CORE 6.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Device:Startup 1.0.1
